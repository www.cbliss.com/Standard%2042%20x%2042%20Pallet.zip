# Autodesk Inventor part: Timber 02
## iProperties
Created: 2005-10
Part Number: Timber 02
Material: Default
Document SubType Name: Modeling
Designer: KLC
Author: KLC
## Feature names
1. Extrusion4
