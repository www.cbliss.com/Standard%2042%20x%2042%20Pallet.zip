# Autodesk Inventor assembly: Standard 42 x 42 Pallet
## iProperties
Created: 2005-10
Part Number: Standard 42 x 42 Pallet
Document SubType Name: Assembly
Designer: KLC
Author: KLC
