# Autodesk Inventor part: Timber 01
## iProperties
Created: 2005-10
Part Number: Timber 01
Material: Default
Document SubType Name: Modeling
Designer: KLC
Author: KLC
## Feature names
1. Extrusion4
